# Keil uVision project First_Project.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: First_Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=4
  c include: .\FWD_ES_Advanced\MCAL;.\FWD_ES_Advanced\MCAL\Config;.\FWD_ES_Advanced\MCAL\Common;.\FWD_ES_Advanced\MCAL\Inc
  asm include: .\FWD_ES_Advanced\MCAL\Common;.\FWD_ES_Advanced\MCAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./FWD_ES_Advanced/MCAL/: SysTick.c Port.c Dio.c IntCtrl.c
  group APPLICATION
    ./FWD_ES_Advanced/APPLICATION/Blink/: main.c
  group Config
    ./FWD_ES_Advanced/MCAL/Config/: SysTick_Lcfg.c Port_Lcfg.c IntCtrl_Lcfg.c
  group HAL
    ./FWD_ES_Advanced/HAL/LED/: LED.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
